# Keil uVision project lib_delay.uvprojx, settings and files
target lib_delay (6160000::V6.16::ARMCLANG)
  device: LPC1549JBD64 NXP
  pack: Keil.LPC1500_DFP.1.2.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x02000000,0x9000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lib_delay (library)
  c flags: Optim=5 oTime=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CORE_M3
  c include: .\inc;..\lib_lpc_chip_15xx\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x9000
  group src
    ./src/: delay.c
  group inc
    ./inc/: delay.h
software components: CMSIS:CORE 5.5.0
