# Keil uVision project lib_lpc_chip_15xx.uvprojx, settings and files
target lib_lpc_chip_15xx (6160000::V6.16::ARMCLANG)
  device: LPC1549JBD64 NXP
  pack: Keil.LPC1500_DFP.1.2.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x02000000,0x9000) CPUTYPE("Cortex-M3") CLOCK(75000000) ELITTLE
  output: lib_lpc_chip_15xx (library)
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CORE_M3
  c include: .\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x9000
  group inc
    ./inc/: acmp_15xx.h adc_15xx.h chip.h clock_15xx.h cmsis.h crc_15xx.h dac_15xx.h dma_15xx.h eeprom.h fmc_15xx.h gpio_15xx.h gpiogroup_15xx.h i2c_common_15xx.h i2cm_15xx.h i2cs_15xx.h inmux_15xx.h iocon_15xx.h lpc_types.h mrt_15xx.h pinint_15xx.h pmu_15xx.h ring_buffer.h ritimer_15xx.h rom_adc_15xx.h rom_can_15xx.h rom_dma_15xx.h rom_i2c_15xx.h rom_pwr_15xx.h rom_spi_15xx.h rom_uart_15xx.h romapi_15xx.h rtc_15xx.h sct_15xx.h sct_pwm_15xx.h sctipu_15xx.h sys_config.h sysctl_15xx.h spi_15xx.h swm_15xx.h uart_15xx.h usbd_15xx.h wwdt_15xx.h error.h iap.h stopwatch.h rtc_ut.h usbd.h usbd_adc.h usbd_cdc.h usbd_cdcuser.h usbd_core.h usbd_desc.h usbd_dfu.h usbd_dfuuser.h usbd_hid.h usbd_hiduser.h usbd_hw.h usbd_msc.h usbd_mscuser.h usbd_rom_api.h
  group src
    ./src/: acmp_15xx.c adc_15xx.c chip_15xx.c clock_15xx.c crc_15xx.c dac_15xx.c dma_15xx.c eeprom.c gpio_15xx.c i2c_common_15xx.c i2cm_15xx.c i2cs_15xx.c iocon_15xx.c pinint_15xx.c pmu_15xx.c ring_buffer.c ritimer_15xx.c rtc_15xx.c sct_15xx.c sct_pwm_15xx.c sctipu_15xx.c sysctl_15xx.c sysinit_15xx.c spi_15xx.c stopwatch_15xx.c swm_15xx.c uart_15xx.c wwdt_15xx.c iap.c rtc_ut.c
software components: CMSIS:CORE 5.5.0
