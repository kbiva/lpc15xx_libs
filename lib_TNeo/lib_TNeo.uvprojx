# Keil uVision project lib_TNeo.uvprojx, settings and files
target lib_TNeo (6160000::V6.16::ARMCLANG)
  device: LPC1549JBD64 NXP
  pack: Keil.LPC1500_DFP.1.2.1
  cpu: IRAM(0x02000000,0x9000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lib_TNeo (library)
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\src;.\src\core;.\src\core\internal;.\src\arch
  asm include: .\src;.\src\core
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x9000
  group core
    ./src/core/: tn_dqueue.c tn_eventgrp.c tn_fmem.c tn_list.c tn_mutex.c tn_sem.c tn_sys.c tn_tasks.c tn_timer.c tn_timer_dyn.c tn_timer_static.c
  group arch
    ./src/arch/cortex_m/: tn_arch_cortex_m.S tn_arch_cortex_m_c.c tn_arch_cortex_m3_gcc.s
